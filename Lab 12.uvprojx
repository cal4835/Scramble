# Keil uVision project Lab 12.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lab 12
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: Ex_12.s Notes and TODO.txt
    ../Lab 9/: DIVU.lib Exercise05.lib Exercise06.lib Exercise07_Circular_FIFO_Queue.lib Exercise07_Custom_IO.lib Exercise07_QTest.lib Start.s
